# Keil uVision project template.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c misc: --diag_suppress=68,111,188,223,546,1295
  c include: .\HARDWARE\KEY;.\HARDWARE\USART;.\HARDWARE\LED;.\USER;.\FreeRTOS\Source\include;.\FreeRTOS\Source\portable\RVDS\ARM_CM3;.\Libraries\FWLIB\inc;.\Libraries\FWLIB\src;.\Libraries\CORE;.\HARDWARE\DMA;.\HARDWARE\LCD;.\HARDWARE\TIMER;.\Middlewares\LVGL\GUI;.\Middlewares\LVGL\GUI\lvgl;.\Middlewares\LVGL\GUI\lvgl\src;.\Middlewares\LVGL\GUI\lvgl\examples\porting
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_conf.h stm32f4xx.h system_stm32f4xx.h stm32f4xx_it.h delay.c
  group HARDWARE
    ./HARDWARE/LED/: led.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/USART/: usart.c
    ./HARDWARE/DMA/: dma.c
    ./HARDWARE/LCD/: lcd.c
    ./HARDWARE/TIMER/: timer.c
  group FWLIB
    ./Libraries/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CORE
    ./Libraries/CORE/: startup_stm32f40_41xxx.s
  group lvgl/porting
    ./Middlewares/LVGL/GUI/lvgl/examples/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c
    ./Middlewares/LVGL/GUI/lvgl/src/: lv_init.c
  group lvgl/core
    ./Middlewares/LVGL/GUI/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
  group lvgl/dev
    ./Middlewares/LVGL/GUI/lvgl/src/dev/sdl/: lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_window.c
    ./Middlewares/LVGL/GUI/lvgl/src/dev/input/touchscreen/: lv_nuttx_touchscreen.c
    ./Middlewares/LVGL/GUI/lvgl/src/dev/disp/drm/: lv_linux_drm.c
    ./Middlewares/LVGL/GUI/lvgl/src/dev/disp/fb/: lv_linux_fbdev.c
    ./Middlewares/LVGL/GUI/lvgl/src/dev/disp/lcd/: lv_nuttx_lcd.c
  group lvgl/disp
    ./Middlewares/LVGL/GUI/lvgl/src/disp/: lv_disp.c
  group lvgl/draw
    ./Middlewares/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_cache_builtin.c lv_img_decoder.c
    ./Middlewares/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_bg_img.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c
    ./Middlewares/LVGL/GUI/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c
  group lvgl/font
    ./Middlewares/LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl/indev
    ./Middlewares/LVGL/GUI/lvgl/src/indev/: lv_indev.c lv_indev_scroll.c
  group lvgl/layouts
    ./Middlewares/LVGL/GUI/lvgl/src/layouts/flex/: lv_flex.c
    ./Middlewares/LVGL/GUI/lvgl/src/layouts/grid/: lv_grid.c
  group lvgl/libs
    ./Middlewares/LVGL/GUI/lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ./Middlewares/LVGL/GUI/lvgl/src/libs/bmp/: lv_bmp.c
    ./Middlewares/LVGL/GUI/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ./Middlewares/LVGL/GUI/lvgl/src/libs/freetype/: lv_freetype.c lv_ftsystem.c
    ./Middlewares/LVGL/GUI/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ./Middlewares/LVGL/GUI/lvgl/src/libs/gif/: gifdec.c lv_gif.c
    ./Middlewares/LVGL/GUI/lvgl/src/libs/png/: lodepng.c lv_png.c
    ./Middlewares/LVGL/GUI/lvgl/src/libs/qrcode/: lv_qrcode.c
    ./Middlewares/LVGL/GUI/lvgl/src/libs/rlottie/: lv_rlottie.c
    ./Middlewares/LVGL/GUI/lvgl/src/libs/sjpg/: lv_sjpg.c tjpgd.c
    ./Middlewares/LVGL/GUI/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
  group lvgl/misc
    ./Middlewares/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_palette.c lv_profiler_builtin.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl/osal
    ./Middlewares/LVGL/GUI/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_pthread.c
  group lvgl/others
    ./Middlewares/LVGL/GUI/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ./Middlewares/LVGL/GUI/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ./Middlewares/LVGL/GUI/lvgl/src/others/gridnav/: lv_gridnav.c
    ./Middlewares/LVGL/GUI/lvgl/src/others/ime/: lv_ime_pinyin.c
    ./Middlewares/LVGL/GUI/lvgl/src/others/imgfont/: lv_imgfont.c
    ./Middlewares/LVGL/GUI/lvgl/src/others/monkey/: lv_monkey.c
    ./Middlewares/LVGL/GUI/lvgl/src/others/msg/: lv_msg.c
    ./Middlewares/LVGL/GUI/lvgl/src/others/snapshot/: lv_snapshot.c
    ./Middlewares/LVGL/GUI/lvgl/src/others/sysmon/: lv_sysmon.c
  group lvgl/stdlib
    ./Middlewares/LVGL/GUI/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ./Middlewares/LVGL/GUI/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ./Middlewares/LVGL/GUI/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ./Middlewares/LVGL/GUI/lvgl/src/stdlib/: lv_mem.c
  group lvgl/themes
    ./Middlewares/LVGL/GUI/lvgl/src/themes/basic/: lv_theme_basic.c
    ./Middlewares/LVGL/GUI/lvgl/src/themes/default/: lv_theme_default.c
    ./Middlewares/LVGL/GUI/lvgl/src/themes/mono/: lv_theme_mono.c
    ./Middlewares/LVGL/GUI/lvgl/src/themes/: lv_theme.c
  group lvgl/tick
    ./Middlewares/LVGL/GUI/lvgl/src/tick/: lv_tick.c
  group lvgl/widgets
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/animimg/: lv_animimg.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/arc/: lv_arc.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/bar/: lv_bar.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/btn/: lv_btn.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/btnmatrix/: lv_btnmatrix.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/canvas/: lv_canvas.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/chart/: lv_chart.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/img/: lv_img.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/imgbtn/: lv_imgbtn.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/label/: lv_label.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/led/: lv_led.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/line/: lv_line.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/list/: lv_list.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/menu/: lv_menu.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/meter/: lv_meter.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/roller/: lv_roller.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/slider/: lv_slider.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/span/: lv_span.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/spinner/: lv_spinner.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/switch/: lv_switch.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/table/: lv_table.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/tabview/: lv_tabview.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/textarea/: lv_textarea.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/tileview/: lv_tileview.c
    ./Middlewares/LVGL/GUI/lvgl/src/widgets/win/: lv_win.c
